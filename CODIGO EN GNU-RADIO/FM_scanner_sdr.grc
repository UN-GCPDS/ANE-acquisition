options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fc
  id: variable
  parameters:
    value: python_mod.sweeper(fun_prob1)
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: frequency
  id: variable_qtgui_label
  parameters:
    label: Frequencia
    type: real
    value: fc
  states: {}
- name: fun_prob1
  id: variable_function_probe
  parameters:
    block_id: probSign1
    function_name: level
    poll_rate: '1'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.2'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: samp_rate/5
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_peak_detector_xb_0
  id: blocks_peak_detector_xb
  parameters:
    alpha: '0.001'
    look_ahead: '10'
    threshold_factor_fall: '0.15'
    threshold_factor_rise: '0.1'
    type: float
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: complex
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.15'
    init: '0'
    low: '0.1'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '1000000'
    decim: '5'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '10000'
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: Sweeper Module
  states: {}
- name: probSign1
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: python_mod
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\r\nimport sys \r\nf1=94800000\r\nf2=163000000\r\nf=f1\r\nstep=100000\r\n\r\ndef sweeper(prob_lvl):\r\n    global f\r\n    if (prob_lvl ==0):\r\n        f+=step\r\n    if f>=f2:\r\n        f=f1\r\n    else:\r\n        print(f)\r\n        return f"
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: fc
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: fc
    fftsize: '1024'
    rate: '5'
    type: complex
    wintype: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: fc
    fftsize: '1024'
    rate: '5'
    type: complex
    wintype: window.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    type: fff
  states: {state: disabled}
- name: rt
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: ''
    type: float
  states: {}
- name: rtlsdr_source_0_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: fc
    gain0: '25'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_peak_detector_xb_0, '0', blocks_char_to_float_0, '0']
- [blocks_rms_xx_0, '0', blocks_peak_detector_xb_0, '0']
- [blocks_rms_xx_0, '0', blocks_threshold_ff_0, '0']
- [blocks_rms_xx_0, '0', rt, '0']
- [blocks_threshold_ff_0, '0', probSign1, '0']
- [blocks_threshold_ff_0, '0', qtgui_number_sink_1, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0, '0', blocks_rms_xx_0, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [rtlsdr_source_0_0, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0_0, '0', qtgui_freq_sink_x_0, '0']
- [rtlsdr_source_0_0, '0', qtgui_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0

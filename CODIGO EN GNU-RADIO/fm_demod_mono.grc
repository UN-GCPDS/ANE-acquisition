options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: Freq
  id: variable
  parameters:
    value: python.sweeper(fun_prob)
  states: {}
- name: Frequency
  id: variable_qtgui_label
  parameters:
    label: Frequency
    type: real
    value: Freq
  states: {}
- name: audio_sample_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: fun_prob
  id: variable_function_probe
  parameters:
    block_id: probSign
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: radio_freq
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: '88000000'
    step: '100000'
    stop: '108000000'
    value: '95100000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1024000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    start: '-20'
    step: '1'
    stop: '10'
    value: '-6'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '15000'
    audio_stop: '18000'
    chan_rate: samp_rate
    comment: Demodulate the FM signal
    deviation: '75000'
    gain: '1'
    tau: '50e-6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '50'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: audio_sink_1
  id: audio_sink
  parameters:
    samp_rate: audio_sample_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(1.*(volume)/10)
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: Filter the FM band
    cutoff_freq: '80000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '10000'
    win: window.WIN_HAMMING
  states: {}
- name: probSign
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: python
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\r\n\r\nf1 = 77000000\r\nf2 = 108000000\r\nf = f1\r\n\r\nstep = 100000\r\n\r\ndef sweeper(prob_lvl):\r\n    global f1, f2, f, step\r\n    if prob_lvl:\r\n        f += step\r\n    if f >= f2: \r\n        f=f1\r\n    return f"
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: Freq
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    size: '1024'
    srate: audio_sample_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '250000'
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    comment: Resample to audio frequency (48 kHz)
    decim: '64'
    interp: '3'
    taps: ''
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: rtl=0
    bb_gain0: '20'
    freq0: Freq
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', rational_resampler_xxx_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_1, '0']
- [blocks_throttle2_0, '0', probSign, '0']
- [low_pass_filter_0, '0', analog_fm_demod_cf_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_time_sink_x_0, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
